Commit message: rb1 urdf corrected

File: rbpodo_description/robots/rb1_500es_u.urdf (robot description, URDF)
Before this commit: robot rb1_500es_u, 8 links, 7 joints
Joints:
- joint wrist2: origin xyz=0 -0.0948 0.2198 rpy=0 0 0 -> xyz=0 0 0.2198 rpy=0 0 0
